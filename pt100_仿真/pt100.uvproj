# Keil uVision project pt100.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: pt100 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group 源组 1
    ./: STARTUP.A51 main.c
    ./src/: 1602.c adc0804.c dev_l298n.c pt100.c timer.c
